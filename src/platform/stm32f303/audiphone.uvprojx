# Keil uVision project audiphone.uvprojx, settings and files
target target (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F303RE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: audiphone +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F303xE USE_STDPERIPH_DRIVER USE_AGC_SPEEX
  c include: ..\..\platform;..\..\..\src;..\stm32f303;..\..\..\3rdparty\STM32F30x_StdPeriph_Driver\inc;..\..\..\3rdparty\CMSIS\Include;..\..\..\3rdparty\CMSIS\Device\ST\STM32F30x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group common
    ../../common/: ap_log.c ap_delay.c
  group base
    ../../base/: ap_agc_simple.c ap_main.c ap_ringbuffer.c ap_agc_speex.c
  group platform
    ./: ap_hw_adc.c ap_hw_dac.c ap_hw_system.c ap_hw_uart.c ap_hw_timer.c stm32f30x_it.c system_stm32f30x.c ap_hw_op.c
  group CMSIS
    ../../../3rdparty/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group STM32F10x_Speex_Lib
    ../../../3rdparty/STM32F10x_Speex_Lib/libspeex/: window.c bits.c exc_10_32_table.c gain_table_lbr.c lpc.c lsp.c speex.c speex_callbacks.c speex_header.c buffer.c high_lsp_tables.c lsp_tables_nb.c preprocess.c filterbank.c fftwrap.c kiss_fft.c kiss_fftr.c mdf.c
    ../../../3rdparty/STM32F10x_Speex_Lib/STM32/libspeex/: modes.c nb_celp.c quant_lsp.c vq.c cb_search.c filters.c ltp.c
  group STM32F30x_StdPeriph_Driver
    ../../../3rdparty/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
